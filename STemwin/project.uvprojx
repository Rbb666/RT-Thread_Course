# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32F103xE
  c include: applications;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports\include;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;packages\gt9147-latest\inc;.;rt-thread\include;rt-thread\components\libc\compilers\common;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;libraries\STM32F1xx_HAL\CMSIS\Include;packages\STemWin-latest\inc\5.32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: FramewinDLG.c drv_gt9147.c drv_lcd.c main.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c div0.c backtrace.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: dataqueue.c ringblk_buf.c pipe.c ringbuffer.c completion.c workqueue.c waitqueue.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/ports/: drv_sram.c sdcard_port.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_common.c drv_usart.c drv_soft_i2c.c drv_sdio.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: ffunicode.c ff.c dfs_elm.c
  group finsh
    rt-thread/components/finsh/: shell.c msh_file.c msh.c cmd.c
  group gt9147
    packages/gt9147-latest/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c object.c kservice.c timer.c memheap.c components.c ipc.c device.c thread.c idle.c scheduler.c mempool.c irq.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_crc.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_i2c.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STemWin
    packages/STemWin-latest/src/: GUI_X_Touch_Analog.c GUI_X_OS.c LCDConf_FlexColor_Template.c GUIConf.c GUIDRV_Template.c STemWin532_CM3_OS_Keil.lib
