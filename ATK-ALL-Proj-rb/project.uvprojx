# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32F103xE
  c include: applications;rt-thread\components\net\at\include;rt-thread\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\esp8266;packages\button-v1.0.1;packages\cJSON-v1.0.2;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports\include;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;GUI;GUI\lvgl;GUI\lvgl_driver;GUI\lv_examples;GUI_APP;HARDWARE;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\none-gcc;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;libraries\STM32F1xx_HAL\CMSIS\Include;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;SYSTEM\sys;rt-thread\components\utilities\ulog;packages\webclient-v2.1.2\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: UART_APP.c MQTT_APP.c drv_lcd.c FileSystem.c FramewinDLG.c Button_APP.c main.c
  group AT
    rt-thread/components/net/at/at_socket/: at_socket.c
    rt-thread/components/net/at/src/: at_utils.c at_client.c at_cli.c
  group at_device
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group button_drive
    packages/button-v1.0.1/: button.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON_util.c cJSON.c cJSON_port.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: ringbuffer.c dataqueue.c completion.c ringblk_buf.c waitqueue.c workqueue.c pipe.c
  group Drivers
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/ports/: drv_sram.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_adc.c drv_soft_i2c.c drv_sdio.c drv_usart.c drv_common.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
  group finsh
    rt-thread/components/finsh/: shell.c msh_file.c msh.c cmd.c
  group GUI
    GUI/lvgl/src/lv_objx/: lv_ta.c lv_gauge.c lv_cb.c lv_arc.c lv_objx_templ.c lv_ddlist.c lv_led.c lv_imgbtn.c lv_sw.c lv_slider.c lv_list.c lv_tabview.c lv_preload.c lv_canvas.c lv_mbox.c lv_win.c lv_img.c lv_btnm.c lv_table.c lv_cont.c lv_roller.c lv_label.c lv_page.c lv_calendar.c lv_chart.c lv_tileview.c lv_kb.c lv_bar.c lv_line.c lv_spinbox.c lv_lmeter.c lv_btn.c
    GUI/lvgl/src/lv_misc/: lv_anim.c lv_task.c lv_math.c lv_txt.c lv_log.c lv_circ.c lv_templ.c lv_mem.c lv_fs.c lv_gc.c lv_async.c lv_area.c lv_utils.c lv_color.c lv_ll.c
    GUI/lvgl/src/lv_themes/: lv_theme_zen.c lv_theme_nemo.c lv_theme_alien.c lv_theme_default.c lv_theme_mono.c lv_theme_templ.c lv_theme_night.c lv_theme.c lv_theme_material.c
    GUI/lvgl/src/lv_font/: lv_font_roboto_28.c lv_font_fmt_txt.c lv_font.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_unscii_8.c lv_font_roboto_22.c
    GUI/lvgl/src/lv_draw/: lv_draw.c lv_img_cache.c lv_draw_img.c lv_draw_rect.c lv_draw_label.c lv_img_decoder.c lv_draw_triangle.c lv_draw_line.c lv_draw_arc.c lv_draw_basic.c
    GUI/lvgl/src/lv_core/: lv_style.c lv_disp.c lv_obj.c lv_group.c lv_indev.c lv_refr.c
    GUI/lvgl/src/lv_hal/: lv_hal_tick.c lv_hal_disp.c lv_hal_indev.c
    GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group GUI_APP
    GUI_APP/: lv_test_theme_1.c lv_bar_test.c
  group Hardware
    HARDWARE/TOUCH/: ctiic.c touch.c gt9147.c
  group Kernel
    rt-thread/src/: clock.c object.c kservice.c scheduler.c components.c thread.c irq.c ipc.c timer.c device.c memheap.c idle.c mempool.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: syscalls.c libc.c mem_std.c stdio.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c unistd.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_crc.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_adc_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_sd.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group paho-mqtt
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTFormat.c MQTTSerializePublish.c MQTTConnectServer.c MQTTPacket.c MQTTSubscribeServer.c MQTTSubscribeClient.c MQTTConnectClient.c MQTTUnsubscribeServer.c MQTTDeserializePublish.c MQTTUnsubscribeClient.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/impl/: af_inet_at.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
  group SYSTEM
    SYSTEM/sys/: sys.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c
